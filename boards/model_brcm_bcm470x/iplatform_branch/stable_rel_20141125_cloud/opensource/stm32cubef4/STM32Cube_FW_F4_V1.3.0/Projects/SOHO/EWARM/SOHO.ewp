# IAR project SOHO.ewp, settings and files
configuration STM32F429I (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZG ST STM32F429ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F439xx; USE_STM32F429I_DISCO
  ICCARM.CCIncludePath2: ..\Core\inc; ..\Config; ..\..\..\Utilities\CPU; ..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\TP-STM32F429I; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\Middlewares\Third_Party\LwIP\src\include\; ..\..\..\Middlewares\Third_Party\LwIP\src\include\ipv4; ..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\Drivers\BSP\Components\gsl1680; ..\..\..\Drivers\BSP\Components\kd43g20; ..\..\..\Utilities\Fonts; ..\Core\widget\inc; ..\..\..\Drivers\CMSIS\Device\TP\STM32F429I\inc; ..\Config\emWin; ..\Bsp\inc; ..\Widget\inc; ..\Inc; ..\Common\inc; ..\Res\Language; ..\Modules\QuickSetup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: C9UI.bin
  ILINK.IlinkOutputFile: C9UI.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../Drivers/CMSIS/Device/TP/STM32F429I/IAR/: startup_stm32f429xx.s
  group Application/User/BSP
    ../Bsp/src/: Bsp.c
    ../../../Drivers/CMSIS/Device/TP/STM32F429I/src/: stm32f4xx_it.c
  group Application/User/Common
    ../Common/src/: stack.c UI_Common.c
  group Application/User/Core
    ../Core/src/: homeAction.c modules.c
  group Application/User/Init
    ../Init/: main.c
  group Application/User/Modules/QuickSetup
    ../Modules/QuickSetup/: GUI_QuickSetup.c GUI_QuickSetupPorcessBar.c GUI_QuickSetupTime.c
  group Application/User/Res/Fonts
    ../Res/Fonts/: F12DqW3.c F16ASCIICourier.c F16ASCIIHNPMD.c F16DqW3.c
  group Application/User/Res/Image/Common
    ../Res/Image/Common/: BackBmp.c NextBmp.c
  group Application/User/Res/Image/QuickSetup
    ../Res/Image/QuickSetup/: QS_AutoDetectedBmp.c QS_BarFutureBmp.c QS_BarNowBmp.c QS_BarPassedBmp.c
  group Application/User/SPI
    ../SPI/: crc32.c defs.h spi_lib.c txrx.c
  group Application/User/Test
    ../Test/: ButtonTestCase.c MessageBoxTestCase.c ScrollbarTestCase.c TP_Edit_test.c TP_FakeList_Test.c
  group Application/User/Widget/res/Dropdown
    ../Widget/res/Dropdown/: DP_TickBmp.c
  group Application/User/Widget/res/Edit
    ../Widget/res/Edit/: EDIT_DeleteBmp.c EDIT_SoliderBmp.c
  group Application/User/Widget/res/FakeList
    ../Widget/res/FakeList/: FAKELIST_RightArrowBmp.c FAKELIST_SwitchOnBmp.c
  group Application/User/Widget/res/KeyBoard
    ../Widget/res/KeyBoard/: KB_123Bmp.c KB_123PressedBmp.c KB_BgBmp.c KB_CharGuideBmp.c KB_CharGuidePressedBmp.c KB_DelBmp.c KB_DelPressedBmp.c KB_DoneBmp.c KB_DonePressedBmp.c KB_LetterBmp.c KB_LetterPressedBmp.c KB_NumBmp.c KB_NumPressedBmp.c KB_ShiftBmp.c KB_ShiftPressedBmp.c KB_SpaceBmp.c KB_SpacePressedBmp.c KB_SpecharBmp.c KB_SpecharPressedBmp.c
  group Application/User/Widget/res/Slider
    ../Widget/res/Slider/: Slider_CircleBmp.c
  group Application/User/Widget/res/Switch
    ../Widget/res/Switch/: SWITCH_OffBmp.c SWITCH_OffDisBmp.c SWITCH_OnBmp.c SWITCH_OnDisBmp.c
  group Application/User/Widget/src
    ../Widget/src/: TP_ActionBar.c TP_Bmp.c TP_Button.c TP_ChannelSelect.c TP_CheckBox.c TP_Dropdown.c TP_Dropdown_list.c TP_Edit.c TP_FakeList.c TP_FakeList_List.c TP_Icon.c TP_Indicator.c TP_KeyBoard.c TP_Menu.c TP_MessageBox.c TP_Scrollbar.c TP_Slider.c TP_Switch.c TP_Text.c TP_Toast.c
  group Drivers/BSP/Components/LCD
    ../../../Drivers/BSP/Components/kd43g20/: kd43g20.c
  group Drivers/BSP/Components/TS
    ../../../Drivers/BSP/Components/gsl1680/: gsl1680.c mGsl1680.c mSwI2c.c
  group Drivers/BSP/TP-STM32F429I
    ../../../Drivers/BSP/TP-STM32F429I/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/TP/STM32F429I/src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/cms
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/port
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/STemWin/Config
    ../Config/emWin/: GUIConf.c LCDConf_stm32f429i_disco_kd43g20.c
  group Middlewares/STemWin/Library
    ../../../Middlewares/ST/STemWin/Lib/: STemWin524b_CM4_OS_IAR.a
  group Middlewares/STemWin/OS
    ../../../Middlewares/ST/STemWin/OS/: GUI_X_FreeRTOS.c
